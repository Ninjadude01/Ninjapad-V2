## Firmware/boards/shields/custom_macropad/Kconfig.defconfig
```kconfig
if SHIELD_CUSTOM_MACROPAD

config ZMK_KEYBOARD_NAME
    default "NinjapadV2"

endif
```
